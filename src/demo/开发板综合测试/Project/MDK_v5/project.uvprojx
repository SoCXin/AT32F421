# Keil uVision project project.uvprojx, settings and files
target QITAS (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: AT32F421C8T7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.7
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: CopyHex.bat
  AfterMake: fromelf.exe --bin -o ../output(mdk5).bin  ./Objects/@L.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F421C8T7,USE_STDPERIPH_DRIVER
  c include: ..\..\User;..\..\User\Bsp;..\..\User\Bsp\inc;..\..\Libraries\CMSIS\CM4\CoreSupport;..\..\Libraries\CMSIS\CM4\DeviceSupport;..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group User
    ../../User/: main.c at32f4xx_it.c
  group BSP
    ../../User/Bsp/: bsp.c bsp.h
    ../../User/Bsp/src/: bsp_delay.c bsp_led.c bsp_timer.c bsp_key.c bsp_usart.c bsp_flash.c bsp_exit.c bsp_pwm.c bsp_adc.c bsp_ertc.c bsp_i2c_gpio.c bsp_i2c.c bsp_spi.c
  group CMSIS
    ../../Libraries/CMSIS/CM4/DeviceSupport/: system_at32f4xx.c at32f4xx_conf.h
    ../../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f421c8t7.s
  group Libraries
    ../../Libraries/AT32F4xx_StdPeriph_Driver/src/: misc.c at32f4xx_rcc.c at32f4xx_dbgmcu.c at32f4xx_gpio_ex.c at32f4xx_tim.c at32f4xx_usart.c at32f4xx_flash.c at32f4xx_exti.c at32f4xx_syscfg.c at32f4xx_adc.c at32f4xx_ertc.c at32f4xx_pwr.c at32f4xx_i2c.c at32f4xx_spi.c
