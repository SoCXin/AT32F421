# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT32F421C8T7 ArteryTek AT32F421C8T7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: AT32F421C8T7; USE_STDPERIPH_DRIVER; USE_FULL_ASSERT
  ICCARM.CCIncludePath2: ..\..\User; ..\..\User\Bsp; ..\..\User\Bsp\inc; ..\..\Libraries\CMSIS\CM4\CoreSupport; ..\..\Libraries\CMSIS\CM4\DeviceSupport; ..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.hex
  postbuild: CopyHex.bat
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group BSP
    ../../User/Bsp/: bsp.c bsp.h
    ../../User/Bsp/src/: bsp_adc.c bsp_delay.c bsp_ertc.c bsp_exit.c bsp_flash.c bsp_i2c.c bsp_i2c_gpio.c bsp_key.c bsp_led.c bsp_pwm.c bsp_spi.c bsp_timer.c bsp_usart.c
  group CMSIS
    ../../Libraries/CMSIS/CM4/DeviceSupport/: at32f4xx_conf.h system_at32f4xx.c
    ../../Libraries/CMSIS/CM4/DeviceSupport/startup/iar/: startup_at32f421c8t7.s
  group Libraries
    ../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_adc.c at32f4xx_dbgmcu.c at32f4xx_ertc.c at32f4xx_exti.c at32f4xx_flash.c at32f4xx_gpio_ex.c at32f4xx_i2c.c at32f4xx_pwr.c at32f4xx_rcc.c at32f4xx_spi.c at32f4xx_syscfg.c at32f4xx_tim.c at32f4xx_usart.c misc.c
  group User
    ../../User/: at32f4xx_it.c main.c
